File: Eagle/ESPLEDCTRL.sch (EAGLE design)
At the start: 19 parts, among them IC1 74HC1G08GW

Commit message: Update
Parts:
- added SV1, SV2: (no value), con-lstb:MA08-1
